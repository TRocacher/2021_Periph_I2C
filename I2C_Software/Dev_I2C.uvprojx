# Keil uVision project Dev_I2C.uvprojx, settings and files
target Simu (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dev_I2C
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\MyDrivers;.\MyRTC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Sources/: Principal.c
  group Services
    ./MyRTC/: Driver_DS1307.c
  group Drivers
    ./MyDrivers/: MyGPIO.c MyTimer.c MyI2C2.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
